FILESEXTRAPATHS_prepend := "${THISDIR}/connman:"

SRC_URI_append = " file://tweak-service-file.patch"
